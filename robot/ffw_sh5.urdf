Commit message: Change : svelte

File: robot/ffw_sh5.urdf (robot description, URDF)
Before this commit: robot converted_robot, 132 links, 131 joints
Joints:
- joint floating_base: origin xyz=0.0 0.0 0.15 rpy=0.0 0.0 0.0 -> xyz=0.0 0.0 0.0 rpy=0.0 0.0 0.0
